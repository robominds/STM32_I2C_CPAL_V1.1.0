# Keil uVision project Project.uvproj, settings and files
target STM32100E-EVAL (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD_VL, USE_STM32100E_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM32100E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Doc
    ../: readme.txt
  group STM32_CPAL_Driver
    ../../../../../Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
  group STM32_EVAL
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../../../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../../../Utilities/STM32_EVAL_CPAL/STM322xG_EVAL/: Printf.c stm322xg_eval_bmp085_cpal.c
  group STM32F10x
    ../: system_stm32f10x.c
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_xl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_hd_vl.s startup_stm32f10x_hd.s startup_stm32f10x_ld_vl.s startup_stm32f10x_ld.s
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
    ../../../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_lcd.c
    ../../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
  group STM32F2xx
    ../../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_fsmc.c stm32f2xx_sdio.c
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f2xx/: cpal_i2c_hal_stm32f2xx.c
    ../: system_stm32f2xx.c
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
    ../../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c
  group STM32L1xx
    ../: system_stm32l1xx.c
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/arm/: startup_stm32l1xx_md.s
    ../../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_spi.c stm32l1xx_tim.c stm32l1xx_usart.c
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32l1xx/: cpal_i2c_hal_stm32l1xx.c
    ../../../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval_lcd.c
  group User
    ../: main.c cpal_usercallback.c stm32_it.c
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM3210C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32L152-EVAL (ARM-ADS)
  device: STM32L15xxx STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32L1xx;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, USE_STM322xG_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F2xx;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
